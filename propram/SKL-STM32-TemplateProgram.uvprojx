# Keil uVision project SKL-STM32-TemplateProgram.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SKL-STM32-TemplateProgram +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User;.\Basic\sys;.\Hardware\led;.\Basic\delay;.\Basic\flash;.\Basic\usart;.\Basic\rtc;.\Function\function1;.\Basic\i2c;.\Hardware\oled-ssd1306;.\Hardware\servo-pca9685;.\Function\function2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Hardware
    ./Hardware/led/: led..c
    ./Hardware/oled-ssd1306/: oled_ssd1306.c
    ./Hardware/servo-pca9685/: servo_pca9685.c
  group Basic
    ./Basic/sys/: sys.c
    ./Basic/delay/: delay.c
    ./Basic/flash/: flash.c
    ./Basic/usart/: usart.c
    ./Basic/rtc/: rtc.c
    ./Basic/i2c/: i2c.c
  group Function
    ./Function/function1/: function1.c
    ./Function/function2/: function2.c
